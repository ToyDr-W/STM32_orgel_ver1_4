# Keil uVision project STM32uvp.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F302R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32uvp +hex
  BeforeMake: cnf.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ../Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_stm32f302x8.s main.c song_idx.s
