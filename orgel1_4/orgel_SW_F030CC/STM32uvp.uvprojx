# Keil uVision project STM32uvp.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F030CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32uvp +hex
  BeforeMake: cnf.bat
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ../Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: song_idx.s startup_stm32f030.s main.c
